// INTERCEPT-X stepper firmware - hardware-timer step generation.
// FireBeetle 2 ESP32-S3 (DFRobot DFR0975/DFR1145 pin mapping)
// arduino-esp32 3.x timer API (timerBegin(freq)). For 2.x see the notes in setup().
//
// Step pulses are generated by a 10 MHz hardware timer interrupt, so step timing
// no longer depends on loop(). The interrupt checks E-stop and limits before each
// pulse. loop() only handles serial commands, E-stop release, and the LCD.
//
// Untested on hardware: verify the bench checklist before relying on it.

#include <Arduino.h>
#include <U8g2lib.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>
#include <math.h>
#include "driver/gpio.h"

// ---- Pins (unchanged) ----
constexpr uint8_t LIMIT_REV = 3;   // D2, active LOW
constexpr uint8_t LIMIT_FWD = 38;  // D3, active LOW
constexpr uint8_t STEP_PIN = 18;   // D6
constexpr uint8_t DIR_PIN = 9;     // D7
constexpr uint8_t ESTOP_PIN = 5;   // A1, active LOW (NC safety contact recommended)

// Robu 12864B V2.0 LCD: ST7920 in 3-wire serial mode.
// IMPORTANT: LCD PSB (pin 15) MUST connect to GND.
// LCD VDD (pin 2) is 5V. Use level shifters for 3.3V ESP32 signals.
// LCD: RST -> SCL(GPIO2), RS/CS -> MISO(GPIO16),
//      R/W/SID -> MOSI(GPIO15), E/SCLK -> SCK(GPIO17)
constexpr uint8_t LCD_RST = 2;
constexpr uint8_t LCD_CS = 16;
constexpr uint8_t LCD_SID = 15;
constexpr uint8_t LCD_CLK = 17;
U8G2_ST7920_128X64_F_SW_SPI lcd(U8G2_R0, LCD_CLK, LCD_SID, LCD_CS, LCD_RST);

// ---- Motion constants ----
constexpr uint32_t PULSES_PER_MOTOR_REV = 400;
constexpr uint32_t FULL_TRAVEL_PULSES = 34192;   // measured end-to-end; limits take priority
constexpr uint32_t MAX_FREQ = 15000;
constexpr float START_FREQ = 500.0f;
constexpr float ACCEL = 20000.0f;                // pulses/s^2
constexpr uint32_t STEP_TIMER_HZ = 10000000;     // 10 MHz -> 0.1 us tick
constexpr uint32_t ESTOP_RELEASE_STABLE_MS = 100;

// ---- ISR-shared state (volatile) ----
hw_timer_t* stepTimer = nullptr;
volatile bool revEdge = false;
volatile bool fwdEdge = false;
volatile bool running = false;
volatile bool stepLevel = false;                 // STEP pin currently high
volatile bool movingForward = true;
volatile uint32_t stepsRemaining = 0;
volatile uint32_t issuedSteps = 0;
volatile uint32_t targetFreq = 3000;
volatile float currentFreq = 0.0f;
volatile uint64_t halfPeriodTicks = 10000;       // timer ticks per half STEP cycle
volatile int32_t positionPulses = 0;
volatile bool positionKnown = false;
volatile bool estopLatched = false;
volatile bool softwareStopLatched = false;
volatile bool stopPending = false;               // ISR asks loop() to print the stop report
volatile uint32_t motionStartUs = 0;
volatile uint32_t lastElapsedUs = 0;
volatile bool resultValid = false;
const char* volatile stopReason = "READY";

// ---- Loop-only state ----
uint32_t estopReleasedAtMs = 0;
char command[64];
uint8_t commandLen = 0;
bool lcdDirty = true;
bool lcdTestVisible = false;

// ISR-safe pin reads (gpio_get_level is IRAM-safe; digitalRead is not guaranteed to be)
static inline bool IRAM_ATTR revLow()   { return gpio_get_level((gpio_num_t)LIMIT_REV) == 0; }
static inline bool IRAM_ATTR fwdLow()   { return gpio_get_level((gpio_num_t)LIMIT_FWD) == 0; }
static inline bool IRAM_ATTR estopLow() { return gpio_get_level((gpio_num_t)ESTOP_PIN) == 0; }

void IRAM_ATTR onRevLimit() { revEdge = true; }
void IRAM_ATTR onFwdLimit() { fwdEdge = true; }

// Halt step generation. limitPos: 0 = none, 1 = reverse limit (position = full travel),
// 2 = forward limit (position = 0). Safe to call from the ISR or from loop().
void IRAM_ATTR stopMotion(const char* why, uint8_t limitPos) {
  if (!running) return;
  running = false;
  timerStop(stepTimer);
  gpio_set_level((gpio_num_t)STEP_PIN, 0);
  stepLevel = false;
  lastElapsedUs = micros() - motionStartUs;
  stepsRemaining = 0;
  currentFreq = 0.0f;
  resultValid = true;
  if (limitPos == 1) { positionPulses = FULL_TRAVEL_PULSES; positionKnown = true; }
  if (limitPos == 2) { positionPulses = 0; positionKnown = true; }
  stopReason = why;
  stopPending = true;
}

// Recompute the half-period from currentFreq. Half-period in ticks = 5e6 / f (10 MHz timer).
void IRAM_ATTR setHalfPeriodFromFreq(float f) {
  uint64_t t = (uint64_t)(5000000.0f / f);
  halfPeriodTicks = t < 2 ? 2 : t;
}

// Trapezoidal ramp, same logic as the polling version, applied once per completed pulse.
void IRAM_ATTR updateSpeed() {
  const float f = currentFreq;
  const float stopSteps = f > START_FREQ
      ? (f * f - START_FREQ * START_FREQ) / (2.0f * ACCEL)
      : 0.0f;
  float nf = f;
  if ((float)stepsRemaining <= stopSteps) {
    nf = f - ACCEL / f;
    if (nf < START_FREQ) nf = START_FREQ;
  } else if (f < (float)targetFreq) {
    nf = f + ACCEL / f;
    if (nf > (float)targetFreq) nf = (float)targetFreq;
  } else if (f > (float)targetFreq) {
    nf = (float)targetFreq;
  }
  currentFreq = nf;
  setHalfPeriodFromFreq(nf);
}

// Timer interrupt: toggles STEP each half-period. A rising edge issues one pulse,
// a falling edge finishes it and updates the speed for the next pulse.
void IRAM_ATTR onStepTimer() {
  if (!running) return;

  if (!stepLevel) {
    // Before raising STEP: re-check safety, so a limit or E-stop prevents the pulse.
    if (estopLow()) { estopLatched = true; stopMotion("EMERGENCY STOP", 0); return; }
    if (revLow() && fwdLow()) { stopMotion("BOTH LIMITS ACTIVE", 0); return; }
    if (movingForward && (fwdEdge || fwdLow())) { stopMotion("FORWARD LIMIT", 2); return; }
    if (!movingForward && (revEdge || revLow())) { stopMotion("REVERSE LIMIT", 1); return; }
    if (stepsRemaining == 0) { stopMotion("STEPS COMPLETE", 0); return; }

    gpio_set_level((gpio_num_t)STEP_PIN, 1);
    stepLevel = true;
    --stepsRemaining;
    ++issuedSteps;
    if (positionKnown) positionPulses += movingForward ? -1 : 1;
  } else {
    gpio_set_level((gpio_num_t)STEP_PIN, 0);
    stepLevel = false;
    if (stepsRemaining == 0) { stopMotion("STEPS COMPLETE", 0); return; }
    updateSpeed();
    // Arm the next half-period. Timer is already running; this only changes the alarm.
    timerAlarm(stepTimer, halfPeriodTicks, true, 0);
  }
}

// ---- Loop-side helpers ----
bool reverseActive() { return revLow(); }
bool forwardActive() { return fwdLow(); }
bool estopActive() { return estopLow(); }

void latchEstop() {
  if (estopLatched) return;
  estopLatched = true;
  if (running) stopMotion("EMERGENCY STOP", 0);
  else {
    gpio_set_level((gpio_num_t)STEP_PIN, 0);
    stopReason = "EMERGENCY STOP";
    lcdDirty = true;
    lcdTestVisible = false;
  }
  estopReleasedAtMs = 0;
  Serial.println("E-STOP ACTIVE. Motor stopped; release switch to auto-clear software status.");
}

// Print the stop report from loop(). The ISR must not call Serial.
void reportStopIfNeeded() {
  if (!stopPending) return;
  stopPending = false;
  Serial.printf("\nSTOP: %s\nIssued pulses: %lu\nElapsed: %.3f s (%.2f ms)\n",
    stopReason, (unsigned long)issuedSteps,
    lastElapsedUs / 1000000.0f, lastElapsedUs / 1000.0f);
  lcdDirty = true;
  lcdTestVisible = false;
}

// E-stop is ACTIVE-LOW with an external 3.3 V pull-up.
// LOW latches immediately. After ESTOP_RELEASE_STABLE_MS of stable HIGH the
// software latch clears. The old movement never restarts.
void serviceEstop() {
  if (estopActive()) {
    estopReleasedAtMs = 0;
    latchEstop();
    return;
  }
  if (!estopLatched) return;

  const uint32_t now = millis();
  if (estopReleasedAtMs == 0) {
    estopReleasedAtMs = now ? now : 1;
    return;
  }
  if ((uint32_t)(now - estopReleasedAtMs) < ESTOP_RELEASE_STABLE_MS) return;

  if (estopActive()) { estopReleasedAtMs = 0; return; }

  estopLatched = false;
  estopReleasedAtMs = 0;
  lcdDirty = true;
  lcdTestVisible = false;
  stopReason = "READY - ESTOP RELEASED";
  Serial.println("E-STOP RELEASED (A1 HIGH stable). Ready for NEW M command.");
}

void startMove(int32_t steps) {
  if (softwareStopLatched) { Serial.println("BLOCKED SOFTWARE E-STOP"); return; }
  if (estopActive() || estopLatched) {
    latchEstop();
    Serial.println("Movement blocked by E-STOP. Release switch; then send new M command.");
    return;
  }
  if (running) { Serial.println("Busy; send STOP first."); return; }
  if (reverseActive() && forwardActive()) {
    Serial.println("FAULT: Both limits active. Motion blocked."); return;
  }
  const bool forward = steps > 0;
  // Clear stale edge flags BEFORE testing actual levels.
  noInterrupts(); revEdge = false; fwdEdge = false; interrupts();
  if (forward && (forwardActive() || fwdEdge)) {
    Serial.println("Forward limit active; only reverse permitted."); return;
  }
  if (!forward && (reverseActive() || revEdge)) {
    Serial.println("Reverse limit active; only forward permitted."); return;
  }

  movingForward = forward;
  stepsRemaining = steps > 0 ? (uint32_t)steps : (uint32_t)(-(int64_t)steps);
  issuedSteps = 0;
  lastElapsedUs = 0;
  resultValid = false;
  stopReason = "RUNNING";

  currentFreq = (float)targetFreq < START_FREQ ? (float)targetFreq : START_FREQ;
  setHalfPeriodFromFreq(currentFreq);
  gpio_set_level((gpio_num_t)STEP_PIN, 0);
  stepLevel = false;
  // Direction changes well before the first pulse (first half-period is ~1 ms at START_FREQ).
  digitalWrite(DIR_PIN, forward ? HIGH : LOW);

  Serial.printf("MOVE %s; %lu pulses; F %lu; accel %.0f\n",
    forward ? "FORWARD" : "REVERSE", (unsigned long)stepsRemaining,
    (unsigned long)targetFreq, ACCEL);

  lcdDirty = true;
  lcdTestVisible = false;
  motionStartUs = micros();
  running = true;
  // Start the timer with the first half-period.
  timerWrite(stepTimer, 0);
  timerAlarm(stepTimer, halfPeriodTicks, true, 0);
  timerStart(stepTimer);
}

void showStatus() {
  Serial.printf("\nMotor: %s | E-STOP: %s | REV D2: %s | FWD D3: %s\n",
      running ? "RUN" : "IDLE", estopLatched ? "LATCHED" : (estopActive() ? "ACTIVE" : "OK"),
      reverseActive() ? "LOW" : "HIGH", forwardActive() ? "LOW" : "HIGH");
  Serial.printf("F=%lu pulses/s | Current=%.0f | Issued=%lu | Remaining=%lu\n",
      (unsigned long)targetFreq, (double)currentFreq, (unsigned long)issuedSteps, (unsigned long)stepsRemaining);
  if (running) Serial.printf("Moving for %.3f s\n", (micros() - motionStartUs) / 1000000.0);
  else if (resultValid) Serial.printf("Last move: %.3f s | %s\n", lastElapsedUs / 1000000.0, stopReason);
  else Serial.printf("Last event: %s\n", stopReason);
}

// 128 x 64 LCD: refreshed only when the motor is idle, so no LCD transfer runs during motion.
void drawLCD() {
  lcd.clearBuffer();
  lcd.setFont(u8g2_font_6x10_tf);
  lcd.drawStr(0, 9, "INTERCEPT-X");
  lcd.drawHLine(0, 12, 128);
  lcd.setCursor(0, 23);
  lcd.print("M:"); lcd.print(running ? "RUN" : "STOP");
  lcd.print(" E:"); lcd.print(estopLatched || estopActive() ? "TRIP" : "OK");
  lcd.setCursor(0, 33);
  lcd.print("L:R"); lcd.print(reverseActive() ? "ON" : "--");
  lcd.print(" F"); lcd.print(forwardActive() ? "ON" : "--");
  lcd.setCursor(0, 43);
  lcd.print("DIR:"); lcd.print(movingForward ? "FWD" : "REV");
  lcd.setCursor(0, 53);
  lcd.print("P:"); lcd.print(positionKnown ? (long)positionPulses : 0L);
  lcd.setCursor(0, 63);
  if (running) {
    lcd.print("F:"); lcd.print((unsigned long)targetFreq);
  } else if (resultValid) {
    lcd.print("TIME:"); lcd.print(lastElapsedUs / 1000000.0f, 3); lcd.print("s");
  } else {
    lcd.print(estopLatched ? "RELEASE E-STOP" : "READY");
  }
  lcd.sendBuffer();
  lcdDirty = false;
}

void lcdTest() {
  if (running) { Serial.println("LCDTEST allowed only when stopped."); return; }
  lcd.clearBuffer();
  lcd.drawFrame(0, 0, 128, 64);
  lcd.drawBox(5, 5, 20, 20);
  lcd.drawBox(102, 39, 20, 20);
  lcd.setFont(u8g2_font_6x10_tf);
  lcd.drawStr(28, 18, "ST7920 LCD");
  lcd.drawStr(28, 31, "TEST PASS?");
  lcd.drawStr(7, 53, "PSB -> GND");
  lcd.sendBuffer();
  Serial.println("LCD test pattern sent; type LCDSTATUS to restore status.");
  lcdDirty = false;
  lcdTestVisible = true;
}

void processCommand(char* cmd) {
  if (strcmp(cmd, "LCDTEST") == 0) { lcdTest(); return; }
  if (strcmp(cmd, "LCDSTATUS") == 0) {
    lcdTestVisible = false;
    if (!running) drawLCD();
    else Serial.println("Status redraws after motion stops.");
    return;
  }
  if (strcmp(cmd, "SESTOP") == 0) {
    softwareStopLatched = true;
    if (running) stopMotion("SOFTWARE E-STOP", 0);
    Serial.println("SOFTWARE E-STOP LATCHED");
    lcdDirty = true;
    return;
  }
  if (strcmp(cmd, "SCLEAR") == 0) {
    if (running || estopActive() || estopLatched || (reverseActive() && forwardActive())) {
      Serial.println("SCLEAR DENIED"); return;
    }
    softwareStopLatched = false;
    Serial.println("SOFTWARE E-STOP CLEARED");
    lcdDirty = true;
    return;
  }
  if (strcmp(cmd, "HOME") == 0) { startMove((int32_t)(FULL_TRAVEL_PULSES + 1500)); return; } // D3 / forward
  if (strcmp(cmd, "END") == 0)  { startMove(-(int32_t)(FULL_TRAVEL_PULSES + 1500)); return; } // D2 / reverse
  if (strcmp(cmd, "TELEM") == 0) {
    Serial.printf("TEL,%u,%u,%u,%u,%u,%u,%lu,%.0f,%ld,%u,%s\n",
      (unsigned)running, (unsigned)reverseActive(), (unsigned)forwardActive(),
      (unsigned)(estopActive() || estopLatched),
      (unsigned)softwareStopLatched, (unsigned)positionKnown, (unsigned long)targetFreq,
      (double)currentFreq, (long)positionPulses, (unsigned int)stepsRemaining, stopReason);
    return;
  }
  if (strcmp(cmd, "STOP") == 0) {
    if (running) stopMotion("SERIAL STOP", 0);
    else Serial.println("Already stopped.");
    return;
  }
  if (strcmp(cmd, "STATUS") == 0) { showStatus(); return; }
  if (strcmp(cmd, "ESTATUS") == 0) {
    Serial.printf("A1 GPIO5=%s | software E-stop=%s | motor=%s\n",
      estopActive() ? "LOW (PRESSED)" : "HIGH (RELEASED)",
      estopLatched ? "ACTIVE" : "CLEAR", running ? "RUNNING" : "STOPPED");
    return;
  }
  if (strcmp(cmd, "RESET") == 0) {
    serviceEstop();
    Serial.println(estopLatched || estopActive()
      ? "E-STOP still active or release debounce in progress."
      : "E-STOP already clear; new M command required to move.");
    return;
  }
  if (cmd[0] == 'F' && cmd[1] == ' ') {
    if (running) { Serial.println("Cannot change F while moving."); return; }
    errno = 0; char* end = nullptr;
    const unsigned long n = strtoul(cmd + 2, &end, 10);
    if (errno || end == cmd + 2 || *end || cmd[2] == '-' || n < 1 || n > MAX_FREQ) {
      Serial.println("Use F 1 .. F 15000"); return;
    }
    targetFreq = (uint32_t)n;
    lcdDirty = true;
    Serial.printf("Frequency %lu pulses/s; motor target RPM %.1f\n",
      n, n * 60.0f / PULSES_PER_MOTOR_REV);
    return;
  }
  if (cmd[0] == 'M' && cmd[1] == ' ') {
    errno = 0; char* end = nullptr;
    const long n = strtol(cmd + 2, &end, 10);
    if (errno || end == cmd + 2 || *end || n == 0 || n > 1000000 || n < -1000000) {
      Serial.println("Use M +/-1 .. +/-1000000"); return;
    }
    startMove((int32_t)n);
    return;
  }
  Serial.println("Commands: M n | F n | HOME | END | STOP | SESTOP | SCLEAR | STATUS | ESTATUS | TELEM | LCDTEST | LCDSTATUS");
}

void readSerial() {
  for (uint8_t n = 0; n < 16 && Serial.available(); ++n) {
    const char c = (char)Serial.read();
    if (c == '\r' || c == '\n') {
      if (commandLen) {
        command[commandLen] = '\0';
        commandLen = 0;
        processCommand(command);
      }
    } else if (commandLen < sizeof(command) - 1) {
      command[commandLen++] = c >= 'a' && c <= 'z' ? c - ('a' - 'A') : c;
    } else {
      commandLen = 0;
      Serial.println("Command too long");
    }
  }
}

void setup() {
  Serial.begin(115200);
  pinMode(STEP_PIN, OUTPUT); digitalWrite(STEP_PIN, LOW);
  pinMode(DIR_PIN, OUTPUT); digitalWrite(DIR_PIN, LOW);
  pinMode(LIMIT_REV, INPUT_PULLUP);
  pinMode(LIMIT_FWD, INPUT_PULLUP);
  pinMode(ESTOP_PIN, INPUT); // external 3.3V pull-up installed
  estopLatched = estopActive();
  attachInterrupt(digitalPinToInterrupt(LIMIT_REV), onRevLimit, FALLING);
  attachInterrupt(digitalPinToInterrupt(LIMIT_FWD), onFwdLimit, FALLING);

  // Step timer: 10 MHz. The counter runs but has no alarm until a move starts.
  // arduino-esp32 2.x equivalent: stepTimer = timerBegin(0, 8, true); (80 MHz / 8 = 10 MHz)
  //   timerAttachInterrupt(stepTimer, &onStepTimer, true);
  //   and use timerAlarmWrite()/timerAlarmEnable() instead of timerAlarm().
  stepTimer = timerBegin(STEP_TIMER_HZ);
  timerAttachInterrupt(stepTimer, &onStepTimer);
  timerStop(stepTimer);

  lcd.begin();
  // ST7920 contrast is set on the LCD module's potentiometer.
  lcd.clearBuffer();
  lcd.setFont(u8g2_font_6x10_tf);
  lcd.drawFrame(0, 0, 128, 64);
  lcd.drawStr(9, 16, "INTERCEPT-X");
  lcd.drawStr(9, 30, "ROBOTIC CATCHER");
  lcd.drawStr(9, 44, "SYSTEM STARTING");
  lcd.drawStr(9, 57, "CHECKING SAFETY");
  lcd.sendBuffer();
  Serial.println("LCD startup test sent. Check LCD backlight, PSB, contrast and wiring.");
  delay(500);
  lcdDirty = true;
  drawLCD();
  Serial.println("FireBeetle S3 | STEP D6 DIR D7 | limits D2/D3 | E-STOP A1 | hw-timer steps");
  Serial.println("LCD ST7920 serial: RST=SCL, RS=MISO, RW=MOSI, E=SCK, PSB=GND");
  Serial.println("Commands: F 3000; M 2000; M -2000; STOP; STATUS; ESTATUS; LCDTEST; LCDSTATUS");
  if (estopLatched) Serial.println("E-STOP active at boot. Release switch to auto-clear software latch.");
}

void loop() {
  serviceEstop();
  reportStopIfNeeded();
  readSerial();

  // LCD transfers are blocking; redraw only while idle.
  static uint32_t lastLCDms = 0;
  if (!running && !lcdTestVisible && (lcdDirty || (uint32_t)(millis() - lastLCDms) >= 500)) {
    drawLCD();
    lastLCDms = millis();
  }
}
